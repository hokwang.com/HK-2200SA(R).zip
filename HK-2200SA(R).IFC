Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-2200SA(R).IFC
Time: 2022-01-05T02:32:15
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 22SA(R)內盒(072409')
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 22SA(R)飾板-立誼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M5平頭螺絲 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 出風口柵門3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 嵌牆盒修正_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
